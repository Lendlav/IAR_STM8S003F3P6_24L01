# IAR project Controller_NRF24L01_RX.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: SPL\inc; inc; $PROJ_DIR$; osa
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Controller_NRF24L01_RX.hex
  ILINK.IlinkOutputFile: NRF24L01.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenStackSize: 0x080
  General.GenHeapSize: 0x080
  ICCSTM8.CCDefines: NDEBUG; STM8S103
  ICCSTM8.CCIncludePath2: SPL\inc; inc; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: lights_stm8_iar.hex
  ILINK.IlinkOutputFile: lights_stm8_iar.out
  group SPL
    SPL/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group User
    src/: functions.c init.c nrf24l01.c
    ./: rx_main.c stm8s_it.c
